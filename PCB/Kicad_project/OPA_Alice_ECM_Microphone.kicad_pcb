# Repository AXinsLab/ECM_XLR_microphone

File README.md:

# Alice OPA ECM 麦克风

**简介：**使用下水道过滤网设计的DIY全屏蔽麦克风，优点是壳体便宜，益于购买，DIY乐趣颇多，缺点是屏蔽性可能存在不足，3D打印的部分零件需要增加铝膜屏蔽层，略显复杂。电路部分基于Alice OPA 驻极体麦克风电路设计，具有极低的底噪及失真率。  

**版权说明：**本项目允许用户查看、使用、修改源代码。禁止将项目或其衍生作品用于商业目的（例如：销售、作为商业服务的一部分盈利）。用户在使用或分发（包括修改版）时，必须保留原始版权和许可声明（注明出处）

<!-- PROJECT SHIELDS -->

[![Contributors][contributors-shield]][contributors-url]
[![Forks][forks-shield]][forks-url]
[![Stargazers][stars-shield]][stars-url]
[![Issues][issues-shield]][issues-url]
[![MIT License][license-shield]][license-url]
[![BiliBili][bilibili-shield]][bilibili-url]

<!-- PROJECT LOGO -->
<br />

<p align="center">
  
  <h3 align="center">AXin实验室</h3>
  <p align="center">
    生命不息，折腾不止，Axin致力于DIY想要又买不起的产品~
    <br />
    <a href="https://github.com/grant-Gan/ECM_XLR_microphone"><strong>探索本项目的文档 »</strong></a>
    <br />
    <br />
    <a href="https://github.com/grant-Gan/ECM_XLR_microphone">查看Demo</a>
    ·
    <a href="https://github.com/grant-Gan/ECM_XLR_microphone/issues">报告Bug</a>
    ·
    <a href="https://github.com/grant-Gan/ECM_XLR_microphone/issues">提出新特性</a>
  </p>

</p>

## 目录

- [Roadmap](#roadmap)
- [文件目录说明](#文件目录说明)
- [零件选型](#零件选型)
    1. [音头](#音头)
    2. [屏蔽网](#屏蔽网)
    3. [运算放大器](#运算放大器)
    4. [1G电阻](#1g电阻)
    5. [卡侬接头](#卡侬接头)
    6. [螺丝螺母](#螺丝螺母)
    7. [其它](#其它)
- [PCB焊接](#pcb焊接)
- [作者](#作者)
- [版权说明](#版权说明)

# Roadmap

待增加功能：
1. 增加75Hz低切开关
2. 增加-10dB衰减开关，提升麦克风可录制的最大升压
3. 增加7kHz以后3dB shelf调音电路

### 文件目录说明

```
ECM_XLR_Microphone
├── .gitignore
├── LICENSE
├── README.md
├── /3D_Models
│   ├── Full_Models_3D_Printer.stl
│   ├── 上盖.stl
│   ├── 下盖.stl
│   ├── 咪头外壳.stl
│   └── 咪头支架_30mm.stl
├── /Images
│   └── Logo.png
├── /PCB
│   ├── /Gerber
│   │   └── Alice_OPA_Gerber.zip
│   ├── /Kicad_project
│   │   ├── Alice_OPA_ECM_Microphone.kicad_pcb
│   │   ├── Alice_OPA_ECM_Microphone.kicad_pro
│   │   ├── Alice_OPA_ECM_Microphone.kicad_sch
│   │   └── Alice_OPA_ECM_Microphone.round-tracks-config
│   ├── /PCB
│   │   └── OPA_Alice_ECM_Microphone_PCB.pdf
│   └── /Schematics
│       └── OPA_Alice_ECM_Microphone.pdf
└── /Reference Document
    ├── /Apmlifier
    │   └── TI-反向放大器电路.pdf
    └── /Supply_Design
        ├── CD4584.pdf
        ├── Phantom Power with Operational Amplifiers.pdf
        └── Voltage_multipliers_with_CMOS_gates.pdf
```

### 零件选型
#### 音头
理论上，不带JFET的驻极体音头都可以使用，大家可以自由选择，如视频中所说，C端消费者可以买到的比较靠谱的应该就是得胜捷韵那家的驻极体音头，大家不想折腾的话可以跟我选同款就好。灵敏度建议标准的-34dB
<p align="center">
    
  <p align="center">得胜JY-H25-20</p>
</p>

#### 屏蔽网
理论上，不带JFET的驻极体音头都可以使用，大家可以自由选择，如视频中所说，C端消费者可以买到的比较靠谱的应该就是得胜捷韵那家的驻极体音头，大家不想折腾的话可以跟我选同款就好。灵敏度建议标准的-34dB
<p align="center">
    
  <p align="center">得胜JY-H25-20</p>
</p>

#### 运算放大器
建议使用TI的OPA1642运放，这颗运放输入级为JFET，低噪声高阻抗，并且功耗比较低，声卡幻象电源可以推得动。
<p align="center">
    
  <p align="center">OPA1642</p>
</p>

#### 1G电阻
1G电阻我是在淘宝上买的玻璃釉高压电阻，注意阻值一定要选择1G以上的，小于这个值会导致声音没有低频。
<p align="center">
    
  <p align="center">1G 玻璃釉电阻</p>
</p>

#### 卡侬接头
使用的是科诺恩的三芯卡侬公插座，质量挺不错的，推荐大家使用
<p align="center">
    
  <p align="center">CM-XLR3M</p>
</p>

#### BOM  

详见BOM文件夹中的bom.html文件，下载打开后可以直接浏览器预览  

#### 螺丝螺母 

| 位置      | 型号      | 类型   | 螺丝头类型 | 数量 |
|---------|---------|------|-------|----|
| 上下壳固定 | M2.5*14 | 普通螺丝 | 内六角   | 8  |
| 中空螺柱  | M6*40外径10   | 螺柱 | 内六角   | 1  |
| 中空螺丝  | M6*20孔3.2      | 中空螺丝   | 六角    | 2  |
| 屏蔽网固定| M3*18   | 铆接螺丝 | 十字   | 3(套)  |

#### 其它
其它零件暂时没有需要重点注意的，想起来或者等到后续问的朋友比较多再行补充~

### PCB焊接

等我更新，还没空搞

### 作者

Bilibili:@AXin实验室 小红书:@AXin实验室  闲鱼：@AXin实验室

### 版权说明
本项目采用 **Creative Commons Attribution-NonCommercial-ShareAlike 4.0 International License** 授权。
您可自由地：
*   **共享** — 在任何媒介以任何形式复制、发行本作品
*   **演绎** — 修改、转换或以本作品为基础进行创作

惟须遵守以下条件：
*   **署名** — 您必须给出[适当的署名](https://creativecommons.org/licenses/by-nc-sa/4.0/deed.zh)，提供指向本许可协议的链接，同时标明是否（对原始作品）作了修改。您可以用任何合理的方式来署名，但不得以任何方式暗示许可人为您或您的使用背书。
*   **非商业性使用** — 您不得将本作品用于商业目的。
*   **相同方式共享** — 如果您再混合、转换或者基于本作品进行创作，您必须基于[与原先许可协议相同的许可协议](https://creativecommons.org/licenses/by-nc-sa/4.0/deed.zh) 分发您贡献的作品。

完整的许可条款请见：[LICENSE](LICENSE) 文件。

该项目签署了MIT 授权许可，详情请参阅 [LICENSE.txt](https://github.com/AXinsLab/ECM_XLR_microphone/LICENSE.txt)

<!-- links -->
[your-project-path]:grant-Gan/ECM_XLR_microphone
[contributors-shield]: https://img.shields.io/github/contributors/grant-Gan/ECM_XLR_microphone.svg?style=flat-square
[contributors-url]: https://github.com/grant-Gan/ECM_XLR_microphone/graphs/contributors
[forks-shield]: https://img.shields.io/github/forks/grant-Gan/ECM_XLR_microphone.svg?style=flat-square
[forks-url]: https://github.com/grant-Gan/ECM_XLR_microphone/network/members
[stars-shield]: https://img.shields.io/github/stars/grant-Gan/ECM_XLR_microphone.svg?style=flat-square
[stars-url]: https://github.com/grant-Gan/ECM_XLR_microphone/stargazers
[issues-shield]: https://img.shields.io/github/issues/grant-Gan/ECM_XLR_microphone.svg?style=flat-square
[issues-url]: https://github.com/grant-Gan/ECM_XLR_microphone/issues
[license-shield]: https://img.shields.io/github/license/grant-Gan/ECM_XLR_microphone.svg?style=flat-square
[license-url]: https://github.com/grant-Gan/ECM_XLR_microphone/blob/master/LICENSE.txt
[bilibili-shield]: https://img.shields.io/badge/关注我-FB7299?logo=bilibili&logoColor=white
[bilibili-url]: https://www.bilibili.com/video/BV1rygnzuE4w

## KiCad design PCB/Kicad_project/OPA_Alice_ECM_Microphone.kicad_pcb

Parts:
C1, C7: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C3, C4, C5, C6: 47uF; CP_Elec_8x10.5; Voltage 63V
C8, C9: 22nF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
D1: 12V; D_SMA
J1, J2, J3, J4: Conn_01x01_Pin; F5-9-0.4直筒内绕平行针_触摸弹簧
J5: XLR; Molex_PicoBlade_53398-0371_1x03-1MP_P1.25mm_Vertical
MK1: ECM; Molex_PicoBlade_53398-0271_1x02-1MP_P1.25mm_Vertical
R1: 1G; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R2, R3: 47k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4, R6, R9, R10: 2.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5: 200; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7: 39k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11, R12: 47; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: OPA1642AIDR; SOIC-8_3.9x4.9mm_P1.27mm
U2: TL431DBZ; SOT-23

Connections:
+12V: C1.2, C3.1, R2.1, R5.2, U1.8 (V+)
/Signal_Output_+: C4.2, R4.1, U1.1, U1.2 (-)
/Signal_Output_-: C5.2, R6.2, U1.7
/XLR_2: C8.1, J5.2, R11.2
/XLR_3: C9.1, J5.3, R12.2
GND: C1.1, C2.2, C3.2, C6.2, C7.1, C8.2, C9.2, D1.2 (A), J1.1, J2.1, J3.1, J4.1, J5.1, J5.MP (Pin_4), MK1.1 (-), MK1.MP, R3.2, R8.2, U1.4 (V-), U2.3 (A); also elsewhere on the board
GNDREF: C2.1, R1.2, R2.2, R3.1, U1.5 (+)
unnamed: C4.1, R9.1, R11.1
unnamed: C5.1, R10.1, R12.1
unnamed: MK1.2 (+), R1.1, U1.3 (+)
unnamed: R4.2, R6.1, U1.6 (-)
unnamed 11: R7.2, R8.1, U2.2 (REF); also elsewhere on the board
VCC: C6.1, C7.2, D1.1 (K), R5.1, R7.1, R9.2, R10.2, U2.1 (K); also elsewhere on the board

Notes on the sheet:
Vout = (1+R7/R8) x Vref
实测 ≈ 11.5V
用于测试不同稳压电路底噪，两个稳压电路保留一个即可
≈ 12.25V

Board: 2 copper layers, 38.8 x 75.0 mm, 30 parts (0 on the bottom side), 13 nets.

Other parts of the board:
TL431: TL431DBZ; SOT-23

Their connections:
GND: TL431.3 (A); also elsewhere on the board
unnamed 11: TL431.2 (REF); also elsewhere on the board
VCC: TL431.1 (K); also elsewhere on the board

## Commit log (part)

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2026-01-16 Readme.md update
2026-01-16 docs: update README with project-specific links and info
2026-02-03 新增BOM
2026-05-21 提交项目文件更新
